# Keil uVision project game.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: game +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\..\9.22最终完成;..\user;..\object;..\output
  group main
    ../: main.c
  group user
    ../user/: display.c snake.c random.c
  group src
    ../src/: lcd12864.c delay.c key.c
